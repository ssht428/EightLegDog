# Keil uVision project Project.uvprojx, settings and files
target STM32L152_Disc (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32L152RCTx STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32L152_Disc +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_MDP
  c include: ..\Library\CMSIS\Inc;..\Library\inc;..\Library\STM32L-DISCOVERY;..\Library\STMTouch_Driver\inc;..\User\inc;D:\Program Files\KeilMDK531\ARM\Packs\ARM\CMSIS\5.7.0\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
  group User
    ../User/src/: main.c stm32l1xx_it.c mbcrc.c ps2_spi.c
    ../Library/STM32L-DISCOVERY/: stm32l1_discovery.c
  group StdPeriph_Driver
    ../Library/src/: misc.c stm32l1xx_hal.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group CMSIS
    ../Library/CMSIS/Src/: system_stm32l1xx.c startup_stm32l1xx_mdp.s
